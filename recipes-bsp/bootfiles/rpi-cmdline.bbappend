CMDLINE += "quiet logo.nologo vt.global_cursor_default=0 "
